# Keil uVision project Study_02.uvprojx, settings and files
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\peripheral_stm32f10x\inc;..\stm32_app\Algorithm_App_H;..\stm32_app\Hardware_App_H;..\stm32_app\Peripheral_App_H;..\user;.\App_Create\_H;.\App_Need\_H
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group peripheral_stm32f10x
    ../peripheral_stm32f10x/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hardware_App
    ../stm32_app/Hardware_App_C/: App_LCD.c
  group Peripheral_App
    ../stm32_app/Peripheral_App_C/: App_DMA.c App_USART.c App_EXTI.c App_TIM.c
  group user
    ./: main.c stm32f10x_it.c
  group App_Create
    ./App_Create/_C/: Create_Test.c
  group App_Need
    ./App_Need/_C/: delay.c lcd.c sys.c
target SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: VECT_TAB_SRAM,STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xa000
  memory RVCT9: RAM 0x2000a000 size 0x6000
